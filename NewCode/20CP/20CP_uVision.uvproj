# Keil uVision project 20CP_uVision.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F500 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(24000000)
  output: 20CP_uVision +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 C8051F500_defs.h compiler_defs.h Display.c Display.h main.c
