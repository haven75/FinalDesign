# Keil uVision project CCBII.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F500 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0xFFF) CLOCK(24000000)
  output: CCBII
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
